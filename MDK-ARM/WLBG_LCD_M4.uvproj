# Keil uVision project WLBG_LCD_M4.uvproj, settings and files
target WLBG_LCD (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: WLBG_LCD_M4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CORE_m4;../Drivers/CMSIS/Include;..\include;..\BSP\LCD;..\BSP\text;..\BSP\timer;..\STemWinLibrary522\Config;..\STemWinLibrary522\inc;..\STemWinLibrary522\Lib;..\STemWinLibrary522\OS;..\BSP\usrat;..\BSP\led;..\STemWinLibrary522\lib;..\BSP\can;..\BSP\FT6236
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_rcc.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c communication.c crc16.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ../Drivers/CORE_m4/: startup_stm32f407xx.s
  group Application/BSP
    ../BSP/LCD/: lcd.c
    ../BSP/text/: text.c
    ../BSP/usrat/: usart.c
    ../BSP/timer/: TIM.C
    ../BSP/led/: led.c
    ../Inc/: STM32F407VET6_GT60L16M2K4_KEIL4.lib
    ../Src/: key.c 24cxx.c
    ../BSP/can/: can.c
    ../BSP/FT6236/: FT6236.c
  group STemWin_V522
    ../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../STemWinLibrary522/OS/: GUI_X.c
    ../STemWinLibrary522/lib/: STemWin528_CM4_Keil.lib
  group STemwin_demo
    ../STemWinLibrary522/Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Fonts
    ../BSP/Fonts/: FontSong16.c FontSong32.c FontSong72.c FontSongEx72.c
  group Hanzi
    ../BSP/HanZi/: GUI_Font12.c GUI_Font16.c GUI_Font24.c GUI_Font32.c GUI_UC_EncodeNone.c GUICharPEx.c
  group remark
    ../: 调试备注.txt 设计思路笔记.txt
